# Keil uVision project CE3103_Lab1.uvproj, settings and files
target HelloWorld (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: CE3013_Lab1 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM
  c include: .\LibraryFiles\CORE;.\LibraryFiles\STM32F4xx_Driver\inc;.\LibraryFiles\FreeRTOS_CORE\include;.\LibraryFiles\FreeRTOS_PORTABLE;.\LibraryFiles\SYSTEM\sys;.\LibraryFiles\SYSTEM\delay;.\LibraryFiles\Hardware;..\CE3103_Lab2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./: buzzer.h buzzer.c main.c button.c button.h playsong.c playsong.h uart.c uart.h
  group CORE
    ./: startup_stm32f40_41xxx.s
    ./LibraryFiles/CORE/: stm32f4xx_it.c system_stm32f4xx.c
  group STM32F4xx_Driver
    ./LibraryFiles/STM32F4xx_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ./LibraryFiles/SYSTEM/delay/: delay.c
    ./LibraryFiles/SYSTEM/sys/: sys.c system.c
  group HARDWARE
    ./LibraryFiles/Hardware/: led.c oled.c show.c show.h
  group FREERTOS
    ./LibraryFiles/FreeRTOS_CORE/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./LibraryFiles/FreeRTOS_PORTABLE/: heap_4.c port.c
